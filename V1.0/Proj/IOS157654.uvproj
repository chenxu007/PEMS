# Keil uVision project IOS157654.uvproj, settings and files
target IOS157654 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IOS157654 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\User;..\Bsp;..\IOS15765-4;..\User\Chan;..\User\Chan\WirelessModule;..\User\UTM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c PBuf.c api.c
    ../User/Chan/WirelessModule/: Wlm.c
    ../User/Chan/: Chan.c CheckFrame.c
    ../User/UTM/BSN/: CMD_Ctrl.c CMD_DataTrans.c CMD_FileTrans.c CMD_QueryParam.c CMD_QueryRealData.c CMD_Reset.c CMD_SetParam.c
    ../User/UTM/: Param.c UTM.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_can.c
  group Bsp
    ../Bsp/: M35.c delay.c Bsp.c
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group IOS157654
    ../IOS15765-4/: IOS157654.c
